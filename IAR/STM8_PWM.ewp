# IAR project STM8_PWM.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x200
  General.GenHeapSize: 0x1000
  ICCSTM8.CCIncludePath2: ..\User; ..\Core; ..\Core\STM8S_StdPeriph_Lib\inc; ..\Libraries\TMT; ..\Libraries\SSD1306; ..\Libraries\BM8563; ..\Libraries\mini-printf; ..\Libraries\menu; ..\Libraries\ButtonEvent; ..\User\HAL; ..\Libraries\DS18B20; ..\Libraries\IRremote-3.9.0\src
  ICCSTM8.IccLang: 1
  OBJCOPY.OOCOutputFile: STM8_PWM.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  ICCSTM8.IccLang: 0
  group Core
    ../Core/: Arduino.cpp encoder.cpp exti.cpp gpio.cpp i2c.cpp pwm.cpp spi.cpp timer.c uart.cpp
  group Libraries
    ../Libraries/IRremote-3.9.0/src/: IRremote.hpp
    ../Libraries/TMT/: TMT.cpp
  group STM8S_StdPeriph_Lib
    ../Core/STM8S_StdPeriph_Lib/src/: stm8s_adc1.c stm8s_awu.c stm8s_beep.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_tim4.c stm8s_wwdg.c
  group User
    ../User/: main.cpp
